# Keil uVision project project.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: project +hex
  c flags: Optim=1
  c define: STM32F429_439xx, USE_STDPERIPH_DRIVER
  c misc: --cpp
  c include: .\inc;.\lib\API\inc;.\lib\CMSIS\Device\ST\STM32F4xx\Include;.\lib\MISC\inc;.\lib\STM32F4\inc;.\lib\CMSIS\Include;.\mbed-rtos;.\mbed-rtos\rtos;.\mbed-rtos\rtx;.\mbed-rtos\targets;.\mbed-rtos\rtx\TARGET_ARM7;.\mbed-rtos\rtx\TARGET_CORTEX_A;.\mbed-rtos\rtx\TARGET_CORTEX_M;.\mbed-rtos\targets\TARGET_STM
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group System
    ./src/: stm32f4xx_it.c
    ./inc/: stm32f4xx_it.h stm32f4xx_conf.h
  group CMSIS
    ./lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
    ./lib/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h
  group STM32F4
    ./lib/STM32F4/src/: stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c misc.c
  group API
    ./lib/API/src/: Common.c Delay.c Digital.cpp Systick.c Analog.cpp Timer.cpp Serial.cpp SPI.cpp CAN.cpp I2C.cpp
  group User
    ./src/: main.c
  group Misc
    ./lib/MISC/src/: Average.cpp LCD.cpp
