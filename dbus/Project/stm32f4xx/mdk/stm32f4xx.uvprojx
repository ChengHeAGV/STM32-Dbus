# Keil uVision project stm32f4xx.uvprojx, settings and files
target STM32F4 (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ebox_stm32f4xx
  c flags: Optim=1 OneElfS=1
  c include: ..\..\..\mcu\stm32f4xx\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\mcu\stm32f4xx\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\User;..\..\..\mcu\stm32f4xx\ebox;..\..\..\mcu\stm32f4xx\ebox\core;..\..\..\mcu\stm32f4xx\ebox\Peripherals;..\..\..\common\edriver
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../../../mcu/stm32f4xx/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
    ../../../mcu/stm32f4xx/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Libraries
    ../../../mcu/stm32f4xx/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group ebox_core
    ../../../core/: dtostrf.c itoa.c big_little.cpp list.cpp new.cpp print.cpp ringbuf.cpp util.cpp WString.cpp ebox_core_.h
    ../../../core/mem/: ebox_mem.c
    ../../../core/math/: crc.c LinearRegression.cpp random.cpp
  group ebox_mcu
    ../../../mcu/stm32f4xx/ebox/core/: mcu_core.cpp mcu_mem.c ebox_common.cpp ebox_it.cpp
    ../../../mcu/stm32f4xx/ebox/Peripherals/: ebox_adc.cpp ebox_dac.cpp ebox_gpio.cpp ebox_i2c.cpp ebox_iflash.cpp ebox_pwm.cpp ebox_soft_iic.cpp ebox_soft_spi.cpp ebox_spi.cpp ebox_time.cpp ebox_uart.cpp
    ../../../mcu/stm32f4xx/ebox/: ebox_object.cpp
  group Driver
    ../../../Driver/: fsmc_sram.c
  group edriver
    ../../../common/edriver/: 74HC595.cpp Button.cpp dht11.cpp parallel_gpio.cpp led.cpp ds18b20.cpp lcd_1.8.cpp w5500.cpp
  group User
    ../../../User/: main.cpp bsp.cpp dbus.cpp
    ./: readme.txt
software components: CMSIS:CORE 4.1.0
